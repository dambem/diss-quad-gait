Commit message: Improvements for experimentaiton purposes

File: data/cube.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0.2 1000 1; visual mesh filename=cube.obj scale=0.2 1000 1
